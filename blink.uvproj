# Keil uVision project blink.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11U35/401 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Source Group 1
    ./: startup_LPC11Uxx.s main.c
